# IAR project Cascading_End_Devices.ewp, settings and files
configuration CC1110-EndDevice (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC1110.i51
  ICC8051.CCDefines: MCU_H=<ioCC1110.h>; MRFI_CC1110
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\..\..\Components\bsp; ..\..\..\..\..\Components\bsp\drivers; ..\..\..\..\..\Components\bsp\boards\SRF04EB; ..\..\..\..\..\Components\mrfi; ..\..\..\..\..\Components\SimpliciTI\nwk; ..\..\..\..\..\Components\SimpliciTI\nwk_applications; ..\..\..\..\..\Components\ApplicationFramework
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc1110F32.xcl
configuration CC2430-EndDevice (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2430F128.i51
  ICC8051.CCDefines: MCU_H=<ioCC2430.h>; MRFI_CC2430; xMCU_H=<ioCC2431.h>; xMRFI_CC2431
  ICC8051.CCIncludePath2: ..\..\..\..\..\Components\bsp; ..\..\..\..\..\Components\bsp\drivers; ..\..\..\..\..\Components\bsp\boards\SRF04EB; ..\..\..\..\..\Components\mrfi; ..\..\..\..\..\Components\SimpliciTI\nwk; ..\..\..\..\..\Components\SimpliciTI\nwk_applications
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2430F128.xcl
configuration CC2510-EndDevice (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2510.i51
  ICC8051.CCDefines: MCU_H=<ioCC2510.h>; MRFI_CC2510
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2510.xcl
configuration CC1110-EndDevice2 (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: as above
  group ApplicationFramework
    ../../../../../Components/ApplicationFramework/: applications.h framework.c framework.h log.c radio.c route.c
  group Components/bsp
    ../../../../../Components/bsp/: bsp.c bsp.h bsp_macros.h
    ../../../../../Components/bsp/drivers/code/: uart.c uart_intfc.c
  group Components/mrfi
    ../../../../../Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Components/nwk
    ../../../../../Components/simpliciti/nwk/: nwk.c nwk_api.c nwk_app.h nwk_frame.c nwk_globals.c nwk_QMgmt.c
    ../../../../../Components/SimpliciTI/nwk/: nwk.h nwk_api.h nwk_frame.h nwk_globals.h nwk_QMgmt.h nwk_types.h
  group Components/nwk applications
    ../../../../../Components/simpliciti/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_ping.h nwk_pll.c nwk_security.c nwk_security.h
    ../../../../../Components/SimpliciTI/nwk_applications/: nwk_pll.h
  group peer applications/application/End Device
    ../../../../../Components/Applications/: channel.c logHandle.c logLevel.c scan.c stationData.c surplusCharge.c test.c
    ../../../Applications/: main_babble.c main_linear.c
  group peer applications/Configuration
    Configuration/: smpl_nwk_config.dat
  group peer applications/Configuration/End Device
    Configuration/End_Device/: smpl_config.dat
